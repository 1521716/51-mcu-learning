# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h key.c key.h NiXie.c NiXie.h Timer1.c Timer1.h Motor.c Motor.h INT0.c INT0.h IR.c IR.h Timer0.c Timer0.h
