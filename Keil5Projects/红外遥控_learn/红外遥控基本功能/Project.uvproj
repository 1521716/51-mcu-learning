# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: config.h main.c Delay.h Delay.c LCD1602.h LCD1602.c Timer0.h Timer0.c INT0.h INT0.c IR.c IR.h
