# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c OneWire.c DS18B20.c OneWire.h DS18B20.h
